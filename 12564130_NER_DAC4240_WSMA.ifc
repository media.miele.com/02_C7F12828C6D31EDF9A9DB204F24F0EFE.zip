Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: d343cf91-2180-4b32-bb36-e556f693f3ef, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-26T08:20:23+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12564130_NER_DAC4240_WSMA:28C4240H_NER_12564130_DAC4240_WSMA, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Cast
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1165 mm; Height: 196 mm; Depth: 500 mm
Pset_BuildingElementProxyCommon - Reference: 28C4240H_NER_12564130_DAC4240_WSMA; sets with these values: 2
